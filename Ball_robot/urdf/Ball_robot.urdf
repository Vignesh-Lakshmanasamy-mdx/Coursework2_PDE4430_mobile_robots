Commit message: updated_urdf

File: Ball_robot/urdf/Ball_robot.urdf (robot description, URDF)
Before this commit: robot Ball_robot, 8 links, 7 joints
Links:
- removed link LH
- removed link RH
Joints:
- removed joint LH_joint
- removed joint RH_joint
